# Ansys Electronics Desktop project, version 2024.2
materials:
  vacuum: permittivity=1
  copper: permeability=0.999991 conductivity=58000000

design BB_BUS_PCB (Q3D Extractor, model units mm)
options: SParamCalcMethod=EqTransLine Calculate_Lossy_Dielectrics
geometry:
  PL_L1 [copper] = box(corner=(-148.3mm, -48.05mm, -0.07mm), size=(296.6mm, 43.1mm, 0.07mm))
  h1 = cylinder(axis=Z, base_centre=(-100.5mm, -18.8mm, -0.08mm), radius=2.15mm, height=0.09mm)
  h2 = cylinder(axis=Z, base_centre=(-88.5mm, -18.8mm, -0.08mm), radius=5.5mm, height=0.09mm)
  h3 = cylinder(axis=Z, base_centre=(-6mm, -18.8mm, -0.08mm), radius=2.15mm, height=0.09mm)
  h4 = cylinder(axis=Z, base_centre=(6mm, -18.8mm, -0.08mm), radius=5.5mm, height=0.09mm)
  h5 = cylinder(axis=Z, base_centre=(88.5mm, -18.8mm, -0.08mm), radius=2.15mm, height=0.09mm)
  h6 = cylinder(axis=Z, base_centre=(100.5mm, -18.8mm, -0.08mm), radius=5.5mm, height=0.09mm)
  h7 = box(corner=(2.5mm, -46.5mm, -0.08mm), size=(19mm, 19mm, 0.09mm))
  h8 = cylinder(axis=Z, base_centre=(82.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h9 = cylinder(axis=Z, base_centre=(22.75mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h10 = cylinder(axis=Z, base_centre=(142.75mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h11 = cylinder(axis=Z, base_centre=(-49.25mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h12 = cylinder(axis=Z, base_centre=(-85.25mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h13 = cylinder(axis=Z, base_centre=(-77.25mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h14 = cylinder(axis=Z, base_centre=(-53.25mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h15 = cylinder(axis=Z, base_centre=(90.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h16 = cylinder(axis=Z, base_centre=(2.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h17 = cylinder(axis=Z, base_centre=(-121.25mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h18 = cylinder(axis=Z, base_centre=(26.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h19 = cylinder(axis=Z, base_centre=(110.75mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h20 = cylinder(axis=Z, base_centre=(118.75mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h21 = cylinder(axis=Z, base_centre=(-101.25mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h22 = cylinder(axis=Z, base_centre=(26.75mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h23 = cylinder(axis=Z, base_centre=(-73.25mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h24 = cylinder(axis=Z, base_centre=(98.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h25 = cylinder(axis=Z, base_centre=(34.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h26 = cylinder(axis=Z, base_centre=(-113.25mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h27 = cylinder(axis=Z, base_centre=(102.75mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h28 = cylinder(axis=Z, base_centre=(94.75mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h29 = cylinder(axis=Z, base_centre=(-117.25mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h30 = cylinder(axis=Z, base_centre=(2.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h31 = cylinder(axis=Z, base_centre=(78.75mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h32 = cylinder(axis=Z, base_centre=(50.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h33 = cylinder(axis=Z, base_centre=(42.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h34 = cylinder(axis=Z, base_centre=(70.75mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h35 = cylinder(axis=Z, base_centre=(-61.25mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h36 = cylinder(axis=Z, base_centre=(-47.6mm, -45.2mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h37 = cylinder(axis=Z, base_centre=(-69.25mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h38 = cylinder(axis=Z, base_centre=(58.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h39 = cylinder(axis=Z, base_centre=(33.6mm, -45.2mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h40 = cylinder(axis=Z, base_centre=(122.75mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h41 = cylinder(axis=Z, base_centre=(58.75mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h42 = cylinder(axis=Z, base_centre=(-93.25mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h43 = cylinder(axis=Z, base_centre=(-97.25mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h44 = cylinder(axis=Z, base_centre=(74.75mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h45 = cylinder(axis=Z, base_centre=(-1.25mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h46 = cylinder(axis=Z, base_centre=(-69.25mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h47 = cylinder(axis=Z, base_centre=(130.75mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h48 = cylinder(axis=Z, base_centre=(-65.25mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h49 = cylinder(axis=Z, base_centre=(-37.25mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h50 = cylinder(axis=Z, base_centre=(-77.25mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h51 = cylinder(axis=Z, base_centre=(66.75mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h52 = cylinder(axis=Z, base_centre=(70.75mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h53 = cylinder(axis=Z, base_centre=(126.75mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h54 = cylinder(axis=Z, base_centre=(-85.25mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h55 = cylinder(axis=Z, base_centre=(66.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h56 = cylinder(axis=Z, base_centre=(-13.25mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h57 = cylinder(axis=Z, base_centre=(-69.25mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h58 = cylinder(axis=Z, base_centre=(-85.25mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h59 = cylinder(axis=Z, base_centre=(-105.25mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h60 = cylinder(axis=Z, base_centre=(-21.25mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h61 = cylinder(axis=Z, base_centre=(78.75mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h62 = cylinder(axis=Z, base_centre=(6.75mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h63 = cylinder(axis=Z, base_centre=(-105.25mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h64 = cylinder(axis=Z, base_centre=(58.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h65 = cylinder(axis=Z, base_centre=(-109.25mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h66 = cylinder(axis=Z, base_centre=(47.6mm, -45.2mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h67 = cylinder(axis=Z, base_centre=(86.75mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h68 = cylinder(axis=Z, base_centre=(134.75mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h69 = cylinder(axis=Z, base_centre=(-133.25mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h70 = cylinder(axis=Z, base_centre=(82.75mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h71 = cylinder(axis=Z, base_centre=(-141.25mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h72 = cylinder(axis=Z, base_centre=(82.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h73 = cylinder(axis=Z, base_centre=(62.75mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h74 = cylinder(axis=Z, base_centre=(110.75mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h75 = cylinder(axis=Z, base_centre=(58.75mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h76 = cylinder(axis=Z, base_centre=(-125.25mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h77 = cylinder(axis=Z, base_centre=(74.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h78 = cylinder(axis=Z, base_centre=(70.75mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h79 = cylinder(axis=Z, base_centre=(-32mm, -45.2mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h80 = cylinder(axis=Z, base_centre=(-65.25mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h81 = cylinder(axis=Z, base_centre=(106.75mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h82 = cylinder(axis=Z, base_centre=(18.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h83 = cylinder(axis=Z, base_centre=(-133.25mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h84 = cylinder(axis=Z, base_centre=(-117.25mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h85 = cylinder(axis=Z, base_centre=(-89.25mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h86 = cylinder(axis=Z, base_centre=(-65.25mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h87 = cylinder(axis=Z, base_centre=(-69.25mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h88 = cylinder(axis=Z, base_centre=(-81.25mm, -41.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h89 = cylinder(axis=Z, base_centre=(-57.25mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h90 = cylinder(axis=Z, base_centre=(-53.25mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h91 = cylinder(axis=Z, base_centre=(114.75mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h92 = cylinder(axis=Z, base_centre=(-137.25mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h93 = cylinder(axis=Z, base_centre=(122.75mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h94 = cylinder(axis=Z, base_centre=(-145.25mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h95 = cylinder(axis=Z, base_centre=(-81.25mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h96 = cylinder(axis=Z, base_centre=(-129.25mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h97 = cylinder(axis=Z, base_centre=(90.75mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h98 = cylinder(axis=Z, base_centre=(-30.4mm, -45.2mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h99 = cylinder(axis=Z, base_centre=(90.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h100 = cylinder(axis=Z, base_centre=(-81.25mm, -29.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h101 = cylinder(axis=Z, base_centre=(-61.25mm, -26mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h102 = cylinder(axis=Z, base_centre=(-93.25mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h103 = cylinder(axis=Z, base_centre=(114.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h104 = cylinder(axis=Z, base_centre=(-109.25mm, -45.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h105 = cylinder(axis=Z, base_centre=(-133.25mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h106 = cylinder(axis=Z, base_centre=(62.75mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h107 = cylinder(axis=Z, base_centre=(-125.25mm, -33.5mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h108 = cylinder(axis=Z, base_centre=(-17.25mm, -12mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h109 = cylinder(axis=Z, base_centre=(66.75mm, -8mm, -0.08mm), radius=0.9mm, height=0.09mm)
  h110 = box(corner=(-150.3mm, -50.05mm, -0.08mm), size=(14.05mm, 47.1mm, 0.09mm))
  h111 = box(corner=(136.25mm, -50.05mm, -0.08mm), size=(14.05mm, 47.1mm, 0.09mm))
  PL_L1.subtract(h1..h111)
  PL_L2 [copper] = box(corner=(-148.3mm, -48.05mm, -0.34mm), size=(296.6mm, 43.1mm, 0.07mm))
  h112 = cylinder(axis=Z, base_centre=(-100.5mm, -18.8mm, -0.35mm), radius=5.5mm, height=0.09mm)
  h113 = cylinder(axis=Z, base_centre=(-88.5mm, -18.8mm, -0.35mm), radius=2.15mm, height=0.09mm)
  h114 = cylinder(axis=Z, base_centre=(-6mm, -18.8mm, -0.35mm), radius=5.5mm, height=0.09mm)
  h115 = cylinder(axis=Z, base_centre=(6mm, -18.8mm, -0.35mm), radius=2.15mm, height=0.09mm)
  h116 = cylinder(axis=Z, base_centre=(88.5mm, -18.8mm, -0.35mm), radius=5.5mm, height=0.09mm)
  h117 = cylinder(axis=Z, base_centre=(100.5mm, -18.8mm, -0.35mm), radius=2.15mm, height=0.09mm)
  h118 = box(corner=(-21.5mm, -46.5mm, -0.35mm), size=(19mm, 19mm, 0.09mm))
  h119 = cylinder(axis=Z, base_centre=(-17.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h120 = cylinder(axis=Z, base_centre=(-109.25mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h121 = cylinder(axis=Z, base_centre=(-13.25mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h122 = cylinder(axis=Z, base_centre=(-125.25mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h123 = cylinder(axis=Z, base_centre=(-57.25mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h124 = cylinder(axis=Z, base_centre=(66.75mm, -41.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h125 = cylinder(axis=Z, base_centre=(118.75mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h126 = cylinder(axis=Z, base_centre=(122.75mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h127 = cylinder(axis=Z, base_centre=(-41.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h128 = cylinder(axis=Z, base_centre=(126.75mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h129 = cylinder(axis=Z, base_centre=(118.75mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h130 = cylinder(axis=Z, base_centre=(-33.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h131 = cylinder(axis=Z, base_centre=(126.75mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h132 = cylinder(axis=Z, base_centre=(-85.25mm, -41.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h133 = cylinder(axis=Z, base_centre=(22.75mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h134 = cylinder(axis=Z, base_centre=(-101.25mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h135 = cylinder(axis=Z, base_centre=(-81.25mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h136 = cylinder(axis=Z, base_centre=(-85.25mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h137 = cylinder(axis=Z, base_centre=(-133.25mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h138 = cylinder(axis=Z, base_centre=(22.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h139 = cylinder(axis=Z, base_centre=(138.75mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h140 = cylinder(axis=Z, base_centre=(54.75mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h141 = cylinder(axis=Z, base_centre=(70.75mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h142 = cylinder(axis=Z, base_centre=(-97.25mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h143 = cylinder(axis=Z, base_centre=(-69.25mm, -41.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h144 = cylinder(axis=Z, base_centre=(-81.25mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h145 = cylinder(axis=Z, base_centre=(-49.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h146 = cylinder(axis=Z, base_centre=(98.75mm, -41.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h147 = cylinder(axis=Z, base_centre=(110.75mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h148 = cylinder(axis=Z, base_centre=(-117.25mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h149 = cylinder(axis=Z, base_centre=(18.75mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h150 = cylinder(axis=Z, base_centre=(-113.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h151 = cylinder(axis=Z, base_centre=(-129.25mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h152 = cylinder(axis=Z, base_centre=(-73.25mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h153 = cylinder(axis=Z, base_centre=(110.75mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h154 = cylinder(axis=Z, base_centre=(122.75mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h155 = cylinder(axis=Z, base_centre=(106.75mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h156 = cylinder(axis=Z, base_centre=(-77.25mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h157 = cylinder(axis=Z, base_centre=(50.75mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h158 = cylinder(axis=Z, base_centre=(114.75mm, -41.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h159 = cylinder(axis=Z, base_centre=(-125.25mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h160 = cylinder(axis=Z, base_centre=(-65.25mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h161 = cylinder(axis=Z, base_centre=(118.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h162 = cylinder(axis=Z, base_centre=(-25.25mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h163 = cylinder(axis=Z, base_centre=(-93.25mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h164 = cylinder(axis=Z, base_centre=(-9.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h165 = cylinder(axis=Z, base_centre=(86.75mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h166 = cylinder(axis=Z, base_centre=(-117.25mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h167 = cylinder(axis=Z, base_centre=(-53.25mm, -41.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h168 = cylinder(axis=Z, base_centre=(-113.25mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h169 = cylinder(axis=Z, base_centre=(30.75mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h170 = cylinder(axis=Z, base_centre=(-133.25mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h171 = cylinder(axis=Z, base_centre=(70.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h172 = cylinder(axis=Z, base_centre=(74.75mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h173 = cylinder(axis=Z, base_centre=(70.75mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h174 = cylinder(axis=Z, base_centre=(-129.25mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h175 = cylinder(axis=Z, base_centre=(-89.25mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h176 = cylinder(axis=Z, base_centre=(-45.25mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h177 = cylinder(axis=Z, base_centre=(42.75mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h178 = cylinder(axis=Z, base_centre=(82.75mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h179 = cylinder(axis=Z, base_centre=(110.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h180 = cylinder(axis=Z, base_centre=(-81.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h181 = cylinder(axis=Z, base_centre=(-121.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h182 = cylinder(axis=Z, base_centre=(106.75mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h183 = cylinder(axis=Z, base_centre=(90.75mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h184 = cylinder(axis=Z, base_centre=(-113.25mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h185 = cylinder(axis=Z, base_centre=(94.75mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h186 = cylinder(axis=Z, base_centre=(130.75mm, -41.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h187 = cylinder(axis=Z, base_centre=(-25.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h188 = cylinder(axis=Z, base_centre=(38.75mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h189 = cylinder(axis=Z, base_centre=(-1.25mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h190 = cylinder(axis=Z, base_centre=(114.75mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h191 = cylinder(axis=Z, base_centre=(62.75mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h192 = cylinder(axis=Z, base_centre=(126.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h193 = cylinder(axis=Z, base_centre=(-97.25mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h194 = cylinder(axis=Z, base_centre=(-1.25mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h195 = cylinder(axis=Z, base_centre=(6.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h196 = cylinder(axis=Z, base_centre=(82.75mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h197 = cylinder(axis=Z, base_centre=(-57.25mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h198 = cylinder(axis=Z, base_centre=(22.75mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h199 = cylinder(axis=Z, base_centre=(14.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h200 = cylinder(axis=Z, base_centre=(54.75mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h201 = cylinder(axis=Z, base_centre=(-113.25mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h202 = cylinder(axis=Z, base_centre=(-57.25mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h203 = cylinder(axis=Z, base_centre=(98.75mm, -29.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h204 = cylinder(axis=Z, base_centre=(-25.25mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h205 = cylinder(axis=Z, base_centre=(38.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h206 = cylinder(axis=Z, base_centre=(86.75mm, -33.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h207 = cylinder(axis=Z, base_centre=(-65.25mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h208 = cylinder(axis=Z, base_centre=(86.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h209 = cylinder(axis=Z, base_centre=(-41.25mm, -45.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h210 = cylinder(axis=Z, base_centre=(94.75mm, -8mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h211 = cylinder(axis=Z, base_centre=(-121.25mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h212 = cylinder(axis=Z, base_centre=(66.75mm, -12mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h213 = cylinder(axis=Z, base_centre=(-77.25mm, -41.5mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h214 = cylinder(axis=Z, base_centre=(-73.25mm, -26mm, -0.35mm), radius=0.9mm, height=0.09mm)
  h215 = box(corner=(-150.3mm, -50.05mm, -0.35mm), size=(14.05mm, 47.1mm, 0.09mm))
  h216 = box(corner=(136.25mm, -50.05mm, -0.35mm), size=(14.05mm, 47.1mm, 0.09mm))
  PL_L2.subtract(h112..h216)
  PL_L3 = box(corner=(-148.3mm, -48.05mm, -1.33mm), size=(296.6mm, 43.1mm, 0.07mm))
  h217 = cylinder(axis=Z, base_centre=(-100.5mm, -18.8mm, -1.34mm), radius=2.15mm, height=0.09mm)
  h218 = cylinder(axis=Z, base_centre=(-88.5mm, -18.8mm, -1.34mm), radius=5.5mm, height=0.09mm)
  h219 = cylinder(axis=Z, base_centre=(-6mm, -18.8mm, -1.34mm), radius=2.15mm, height=0.09mm)
  h220 = cylinder(axis=Z, base_centre=(6mm, -18.8mm, -1.34mm), radius=5.5mm, height=0.09mm)
  h221 = cylinder(axis=Z, base_centre=(88.5mm, -18.8mm, -1.34mm), radius=2.15mm, height=0.09mm)
  h222 = cylinder(axis=Z, base_centre=(100.5mm, -18.8mm, -1.34mm), radius=5.5mm, height=0.09mm)
  h223 = box(corner=(2.5mm, -46.5mm, -1.34mm), size=(19mm, 19mm, 0.09mm))
  h224 = cylinder(axis=Z, base_centre=(82.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h225 = cylinder(axis=Z, base_centre=(22.75mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h226 = cylinder(axis=Z, base_centre=(142.75mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h227 = cylinder(axis=Z, base_centre=(-49.25mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h228 = cylinder(axis=Z, base_centre=(-85.25mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h229 = cylinder(axis=Z, base_centre=(-77.25mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h230 = cylinder(axis=Z, base_centre=(-53.25mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h231 = cylinder(axis=Z, base_centre=(90.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h232 = cylinder(axis=Z, base_centre=(2.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h233 = cylinder(axis=Z, base_centre=(-121.25mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h234 = cylinder(axis=Z, base_centre=(26.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h235 = cylinder(axis=Z, base_centre=(110.75mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h236 = cylinder(axis=Z, base_centre=(118.75mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h237 = cylinder(axis=Z, base_centre=(-101.25mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h238 = cylinder(axis=Z, base_centre=(26.75mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h239 = cylinder(axis=Z, base_centre=(-73.25mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h240 = cylinder(axis=Z, base_centre=(98.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h241 = cylinder(axis=Z, base_centre=(34.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h242 = cylinder(axis=Z, base_centre=(-113.25mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h243 = cylinder(axis=Z, base_centre=(102.75mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h244 = cylinder(axis=Z, base_centre=(94.75mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h245 = cylinder(axis=Z, base_centre=(-117.25mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h246 = cylinder(axis=Z, base_centre=(2.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h247 = cylinder(axis=Z, base_centre=(78.75mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h248 = cylinder(axis=Z, base_centre=(50.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h249 = cylinder(axis=Z, base_centre=(42.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h250 = cylinder(axis=Z, base_centre=(70.75mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h251 = cylinder(axis=Z, base_centre=(-61.25mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h252 = cylinder(axis=Z, base_centre=(-47.6mm, -45.2mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h253 = cylinder(axis=Z, base_centre=(-69.25mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h254 = cylinder(axis=Z, base_centre=(58.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h255 = cylinder(axis=Z, base_centre=(33.6mm, -45.2mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h256 = cylinder(axis=Z, base_centre=(122.75mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h257 = cylinder(axis=Z, base_centre=(58.75mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h258 = cylinder(axis=Z, base_centre=(-93.25mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h259 = cylinder(axis=Z, base_centre=(-97.25mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h260 = cylinder(axis=Z, base_centre=(74.75mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h261 = cylinder(axis=Z, base_centre=(-1.25mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h262 = cylinder(axis=Z, base_centre=(-69.25mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h263 = cylinder(axis=Z, base_centre=(130.75mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h264 = cylinder(axis=Z, base_centre=(-65.25mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h265 = cylinder(axis=Z, base_centre=(-37.25mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h266 = cylinder(axis=Z, base_centre=(-77.25mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h267 = cylinder(axis=Z, base_centre=(66.75mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h268 = cylinder(axis=Z, base_centre=(70.75mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h269 = cylinder(axis=Z, base_centre=(126.75mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h270 = cylinder(axis=Z, base_centre=(-85.25mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h271 = cylinder(axis=Z, base_centre=(66.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h272 = cylinder(axis=Z, base_centre=(-13.25mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h273 = cylinder(axis=Z, base_centre=(-69.25mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h274 = cylinder(axis=Z, base_centre=(-85.25mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h275 = cylinder(axis=Z, base_centre=(-105.25mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h276 = cylinder(axis=Z, base_centre=(-21.25mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h277 = cylinder(axis=Z, base_centre=(78.75mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h278 = cylinder(axis=Z, base_centre=(6.75mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h279 = cylinder(axis=Z, base_centre=(-105.25mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h280 = cylinder(axis=Z, base_centre=(58.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h281 = cylinder(axis=Z, base_centre=(-109.25mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h282 = cylinder(axis=Z, base_centre=(47.6mm, -45.2mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h283 = cylinder(axis=Z, base_centre=(86.75mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h284 = cylinder(axis=Z, base_centre=(134.75mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h285 = cylinder(axis=Z, base_centre=(-133.25mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h286 = cylinder(axis=Z, base_centre=(82.75mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h287 = cylinder(axis=Z, base_centre=(-141.25mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h288 = cylinder(axis=Z, base_centre=(82.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h289 = cylinder(axis=Z, base_centre=(62.75mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h290 = cylinder(axis=Z, base_centre=(110.75mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h291 = cylinder(axis=Z, base_centre=(58.75mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h292 = cylinder(axis=Z, base_centre=(-125.25mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h293 = cylinder(axis=Z, base_centre=(74.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h294 = cylinder(axis=Z, base_centre=(70.75mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h295 = cylinder(axis=Z, base_centre=(-32mm, -45.2mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h296 = cylinder(axis=Z, base_centre=(-65.25mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h297 = cylinder(axis=Z, base_centre=(106.75mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h298 = cylinder(axis=Z, base_centre=(18.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h299 = cylinder(axis=Z, base_centre=(-133.25mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h300 = cylinder(axis=Z, base_centre=(-117.25mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h301 = cylinder(axis=Z, base_centre=(-89.25mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h302 = cylinder(axis=Z, base_centre=(-65.25mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h303 = cylinder(axis=Z, base_centre=(-69.25mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h304 = cylinder(axis=Z, base_centre=(-81.25mm, -41.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h305 = cylinder(axis=Z, base_centre=(-57.25mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h306 = cylinder(axis=Z, base_centre=(-53.25mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h307 = cylinder(axis=Z, base_centre=(114.75mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h308 = cylinder(axis=Z, base_centre=(-137.25mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h309 = cylinder(axis=Z, base_centre=(122.75mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h310 = cylinder(axis=Z, base_centre=(-145.25mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h311 = cylinder(axis=Z, base_centre=(-81.25mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h312 = cylinder(axis=Z, base_centre=(-129.25mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h313 = cylinder(axis=Z, base_centre=(90.75mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h314 = cylinder(axis=Z, base_centre=(-30.4mm, -45.2mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h315 = cylinder(axis=Z, base_centre=(90.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h316 = cylinder(axis=Z, base_centre=(-81.25mm, -29.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h317 = cylinder(axis=Z, base_centre=(-61.25mm, -26mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h318 = cylinder(axis=Z, base_centre=(-93.25mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h319 = cylinder(axis=Z, base_centre=(114.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h320 = cylinder(axis=Z, base_centre=(-109.25mm, -45.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h321 = cylinder(axis=Z, base_centre=(-133.25mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h322 = cylinder(axis=Z, base_centre=(62.75mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h323 = cylinder(axis=Z, base_centre=(-125.25mm, -33.5mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h324 = cylinder(axis=Z, base_centre=(-17.25mm, -12mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h325 = cylinder(axis=Z, base_centre=(66.75mm, -8mm, -1.34mm), radius=0.9mm, height=0.09mm)
  h326 = box(corner=(-150.3mm, -50.05mm, -1.34mm), size=(14.05mm, 47.1mm, 0.09mm))
  h327 = box(corner=(136.25mm, -50.05mm, -1.34mm), size=(14.05mm, 47.1mm, 0.09mm))
  PL_L3.subtract(h217..h327)
  PL_L4 = box(corner=(-148.3mm, -48.05mm, -1.6mm), size=(296.6mm, 43.1mm, 0.07mm))
  h328 = cylinder(axis=Z, base_centre=(-100.5mm, -18.8mm, -1.61mm), radius=5.5mm, height=0.09mm)
  h329 = cylinder(axis=Z, base_centre=(-88.5mm, -18.8mm, -1.61mm), radius=2.15mm, height=0.09mm)
  h330 = cylinder(axis=Z, base_centre=(-6mm, -18.8mm, -1.61mm), radius=5.5mm, height=0.09mm)
  h331 = cylinder(axis=Z, base_centre=(6mm, -18.8mm, -1.61mm), radius=2.15mm, height=0.09mm)
  h332 = cylinder(axis=Z, base_centre=(88.5mm, -18.8mm, -1.61mm), radius=5.5mm, height=0.09mm)
  h333 = cylinder(axis=Z, base_centre=(100.5mm, -18.8mm, -1.61mm), radius=2.15mm, height=0.09mm)
  h334 = box(corner=(-21.5mm, -46.5mm, -1.61mm), size=(19mm, 19mm, 0.09mm))
  h335 = cylinder(axis=Z, base_centre=(-17.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h336 = cylinder(axis=Z, base_centre=(-109.25mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h337 = cylinder(axis=Z, base_centre=(-13.25mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h338 = cylinder(axis=Z, base_centre=(-125.25mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h339 = cylinder(axis=Z, base_centre=(-57.25mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h340 = cylinder(axis=Z, base_centre=(66.75mm, -41.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h341 = cylinder(axis=Z, base_centre=(118.75mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h342 = cylinder(axis=Z, base_centre=(122.75mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h343 = cylinder(axis=Z, base_centre=(-41.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h344 = cylinder(axis=Z, base_centre=(126.75mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h345 = cylinder(axis=Z, base_centre=(118.75mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h346 = cylinder(axis=Z, base_centre=(-33.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h347 = cylinder(axis=Z, base_centre=(126.75mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h348 = cylinder(axis=Z, base_centre=(-85.25mm, -41.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h349 = cylinder(axis=Z, base_centre=(22.75mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h350 = cylinder(axis=Z, base_centre=(-101.25mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h351 = cylinder(axis=Z, base_centre=(-81.25mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h352 = cylinder(axis=Z, base_centre=(-85.25mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h353 = cylinder(axis=Z, base_centre=(-133.25mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h354 = cylinder(axis=Z, base_centre=(22.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h355 = cylinder(axis=Z, base_centre=(138.75mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h356 = cylinder(axis=Z, base_centre=(54.75mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h357 = cylinder(axis=Z, base_centre=(70.75mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h358 = cylinder(axis=Z, base_centre=(-97.25mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h359 = cylinder(axis=Z, base_centre=(-69.25mm, -41.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h360 = cylinder(axis=Z, base_centre=(-81.25mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h361 = cylinder(axis=Z, base_centre=(-49.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h362 = cylinder(axis=Z, base_centre=(98.75mm, -41.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h363 = cylinder(axis=Z, base_centre=(110.75mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h364 = cylinder(axis=Z, base_centre=(-117.25mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h365 = cylinder(axis=Z, base_centre=(18.75mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h366 = cylinder(axis=Z, base_centre=(-113.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h367 = cylinder(axis=Z, base_centre=(-129.25mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h368 = cylinder(axis=Z, base_centre=(-73.25mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h369 = cylinder(axis=Z, base_centre=(110.75mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h370 = cylinder(axis=Z, base_centre=(122.75mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h371 = cylinder(axis=Z, base_centre=(106.75mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h372 = cylinder(axis=Z, base_centre=(-77.25mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h373 = cylinder(axis=Z, base_centre=(50.75mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h374 = cylinder(axis=Z, base_centre=(114.75mm, -41.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h375 = cylinder(axis=Z, base_centre=(-125.25mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h376 = cylinder(axis=Z, base_centre=(-65.25mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h377 = cylinder(axis=Z, base_centre=(118.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h378 = cylinder(axis=Z, base_centre=(-25.25mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h379 = cylinder(axis=Z, base_centre=(-93.25mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h380 = cylinder(axis=Z, base_centre=(-9.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h381 = cylinder(axis=Z, base_centre=(86.75mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h382 = cylinder(axis=Z, base_centre=(-117.25mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h383 = cylinder(axis=Z, base_centre=(-53.25mm, -41.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h384 = cylinder(axis=Z, base_centre=(-113.25mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h385 = cylinder(axis=Z, base_centre=(30.75mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h386 = cylinder(axis=Z, base_centre=(-133.25mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h387 = cylinder(axis=Z, base_centre=(70.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h388 = cylinder(axis=Z, base_centre=(74.75mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h389 = cylinder(axis=Z, base_centre=(70.75mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h390 = cylinder(axis=Z, base_centre=(-129.25mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h391 = cylinder(axis=Z, base_centre=(-89.25mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h392 = cylinder(axis=Z, base_centre=(-45.25mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h393 = cylinder(axis=Z, base_centre=(42.75mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h394 = cylinder(axis=Z, base_centre=(82.75mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h395 = cylinder(axis=Z, base_centre=(110.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h396 = cylinder(axis=Z, base_centre=(-81.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h397 = cylinder(axis=Z, base_centre=(-121.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h398 = cylinder(axis=Z, base_centre=(106.75mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h399 = cylinder(axis=Z, base_centre=(90.75mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h400 = cylinder(axis=Z, base_centre=(-113.25mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h401 = cylinder(axis=Z, base_centre=(94.75mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h402 = cylinder(axis=Z, base_centre=(130.75mm, -41.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h403 = cylinder(axis=Z, base_centre=(-25.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h404 = cylinder(axis=Z, base_centre=(38.75mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h405 = cylinder(axis=Z, base_centre=(-1.25mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h406 = cylinder(axis=Z, base_centre=(114.75mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h407 = cylinder(axis=Z, base_centre=(62.75mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h408 = cylinder(axis=Z, base_centre=(126.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h409 = cylinder(axis=Z, base_centre=(-97.25mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h410 = cylinder(axis=Z, base_centre=(-1.25mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h411 = cylinder(axis=Z, base_centre=(6.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h412 = cylinder(axis=Z, base_centre=(82.75mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h413 = cylinder(axis=Z, base_centre=(-57.25mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h414 = cylinder(axis=Z, base_centre=(22.75mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h415 = cylinder(axis=Z, base_centre=(14.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h416 = cylinder(axis=Z, base_centre=(54.75mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h417 = cylinder(axis=Z, base_centre=(-113.25mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h418 = cylinder(axis=Z, base_centre=(-57.25mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h419 = cylinder(axis=Z, base_centre=(98.75mm, -29.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h420 = cylinder(axis=Z, base_centre=(-25.25mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h421 = cylinder(axis=Z, base_centre=(38.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h422 = cylinder(axis=Z, base_centre=(86.75mm, -33.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h423 = cylinder(axis=Z, base_centre=(-65.25mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h424 = cylinder(axis=Z, base_centre=(86.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h425 = cylinder(axis=Z, base_centre=(-41.25mm, -45.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h426 = cylinder(axis=Z, base_centre=(94.75mm, -8mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h427 = cylinder(axis=Z, base_centre=(-121.25mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h428 = cylinder(axis=Z, base_centre=(66.75mm, -12mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h429 = cylinder(axis=Z, base_centre=(-77.25mm, -41.5mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h430 = cylinder(axis=Z, base_centre=(-73.25mm, -26mm, -1.61mm), radius=0.9mm, height=0.09mm)
  h431 = box(corner=(-150.3mm, -50.05mm, -1.61mm), size=(14.05mm, 47.1mm, 0.09mm))
  h432 = box(corner=(136.25mm, -50.05mm, -1.61mm), size=(14.05mm, 47.1mm, 0.09mm))
  PL_L4.subtract(h328..h432)
  pad433 = cylinder(axis=Z, base_centre=(-100.5mm, -18.8mm, -1.6mm), radius=5mm, height=0.07mm)
  h434 = cylinder(axis=Z, base_centre=(-100.5mm, -18.8mm, -1.61mm), radius=2.15mm, height=0.09mm)
  pad433.subtract(h434)
  face435 = box(corner=(-104mm, -22.3mm, 0mm), size=(7mm, 7mm, 0.035mm))
  h436 = cylinder(axis=Z, base_centre=(-100.5mm, -18.8mm, -0.01mm), radius=2.15mm, height=0.055mm)
  face435.subtract(h436)
  pad437 = cylinder(axis=Z, base_centre=(-88.5mm, -18.8mm, -0.07mm), radius=5mm, height=0.07mm)
  h438 = cylinder(axis=Z, base_centre=(-88.5mm, -18.8mm, -0.08mm), radius=2.15mm, height=0.09mm)
  pad437.subtract(h438)
  face439 = box(corner=(-92mm, -22.3mm, 0mm), size=(7mm, 7mm, 0.035mm))
  h440 = cylinder(axis=Z, base_centre=(-88.5mm, -18.8mm, -0.01mm), radius=2.15mm, height=0.055mm)
  face439.subtract(h440)
  pad441 = cylinder(axis=Z, base_centre=(-6mm, -18.8mm, -1.6mm), radius=5mm, height=0.07mm)
  h442 = cylinder(axis=Z, base_centre=(-6mm, -18.8mm, -1.61mm), radius=2.15mm, height=0.09mm)
  pad441.subtract(h442)
  face443 = box(corner=(-9.5mm, -22.3mm, 0mm), size=(7mm, 7mm, 0.035mm))
  h444 = cylinder(axis=Z, base_centre=(-6mm, -18.8mm, -0.01mm), radius=2.15mm, height=0.055mm)
  face443.subtract(h444)
  pad445 = cylinder(axis=Z, base_centre=(6mm, -18.8mm, -0.07mm), radius=5mm, height=0.07mm)
  h446 = cylinder(axis=Z, base_centre=(6mm, -18.8mm, -0.08mm), radius=2.15mm, height=0.09mm)
  pad445.subtract(h446)
  face447 = box(corner=(2.5mm, -22.3mm, 0mm), size=(7mm, 7mm, 0.035mm))
  h448 = cylinder(axis=Z, base_centre=(6mm, -18.8mm, -0.01mm), radius=2.15mm, height=0.055mm)
  face447.subtract(h448)
  pad449 = cylinder(axis=Z, base_centre=(88.5mm, -18.8mm, -1.6mm), radius=5mm, height=0.07mm)
  h450 = cylinder(axis=Z, base_centre=(88.5mm, -18.8mm, -1.61mm), radius=2.15mm, height=0.09mm)
  pad449.subtract(h450)
  face451 = box(corner=(85mm, -22.3mm, 0mm), size=(7mm, 7mm, 0.035mm))
  h452 = cylinder(axis=Z, base_centre=(88.5mm, -18.8mm, -0.01mm), radius=2.15mm, height=0.055mm)
  face451.subtract(h452)
  pad453 = cylinder(axis=Z, base_centre=(100.5mm, -18.8mm, -0.07mm), radius=5mm, height=0.07mm)
  h454 = cylinder(axis=Z, base_centre=(100.5mm, -18.8mm, -0.08mm), radius=2.15mm, height=0.09mm)
  pad453.subtract(h454)
  face455 = box(corner=(97mm, -22.3mm, 0mm), size=(7mm, 7mm, 0.035mm))
  h456 = cylinder(axis=Z, base_centre=(100.5mm, -18.8mm, -0.01mm), radius=2.15mm, height=0.055mm)
  face455.subtract(h456)
  pv457 = cylinder(axis=Z, base_centre=(-9.326mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv458 = cylinder(axis=Z, base_centre=(-9.326mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv459 = cylinder(axis=Z, base_centre=(-7.3777mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv460 = cylinder(axis=Z, base_centre=(-7.3777mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv461 = cylinder(axis=Z, base_centre=(-4.6223mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv462 = cylinder(axis=Z, base_centre=(-4.6223mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv463 = cylinder(axis=Z, base_centre=(-2.674mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv464 = cylinder(axis=Z, base_centre=(-2.674mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv465 = cylinder(axis=Z, base_centre=(85.174mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv466 = cylinder(axis=Z, base_centre=(85.174mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv467 = cylinder(axis=Z, base_centre=(87.1223mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv468 = cylinder(axis=Z, base_centre=(87.1223mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv469 = cylinder(axis=Z, base_centre=(89.8777mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv470 = cylinder(axis=Z, base_centre=(89.8777mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv471 = cylinder(axis=Z, base_centre=(91.826mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv472 = cylinder(axis=Z, base_centre=(91.826mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv473 = cylinder(axis=Z, base_centre=(-103.826mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv474 = cylinder(axis=Z, base_centre=(-103.826mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv475 = cylinder(axis=Z, base_centre=(-101.8777mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv476 = cylinder(axis=Z, base_centre=(-101.8777mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv477 = cylinder(axis=Z, base_centre=(-99.1223mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv478 = cylinder(axis=Z, base_centre=(-99.1223mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv479 = cylinder(axis=Z, base_centre=(-97.174mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv480 = cylinder(axis=Z, base_centre=(-97.174mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv481 = cylinder(axis=Z, base_centre=(2.674mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv482 = cylinder(axis=Z, base_centre=(2.674mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv483 = cylinder(axis=Z, base_centre=(4.6223mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv484 = cylinder(axis=Z, base_centre=(4.6223mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv485 = cylinder(axis=Z, base_centre=(7.3777mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv486 = cylinder(axis=Z, base_centre=(7.3777mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv487 = cylinder(axis=Z, base_centre=(9.326mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv488 = cylinder(axis=Z, base_centre=(9.326mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv489 = cylinder(axis=Z, base_centre=(97.174mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv490 = cylinder(axis=Z, base_centre=(97.174mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv491 = cylinder(axis=Z, base_centre=(99.1223mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv492 = cylinder(axis=Z, base_centre=(99.1223mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv493 = cylinder(axis=Z, base_centre=(101.8777mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv494 = cylinder(axis=Z, base_centre=(101.8777mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv495 = cylinder(axis=Z, base_centre=(103.826mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv496 = cylinder(axis=Z, base_centre=(103.826mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv497 = cylinder(axis=Z, base_centre=(-91.826mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv498 = cylinder(axis=Z, base_centre=(-91.826mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv499 = cylinder(axis=Z, base_centre=(-89.8777mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv500 = cylinder(axis=Z, base_centre=(-89.8777mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv501 = cylinder(axis=Z, base_centre=(-87.1223mm, -22.126mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv502 = cylinder(axis=Z, base_centre=(-87.1223mm, -15.474mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv503 = cylinder(axis=Z, base_centre=(-85.174mm, -20.1777mm, -1.6mm), radius=0.2mm, height=1.6mm)
  pv504 = cylinder(axis=Z, base_centre=(-85.174mm, -17.4223mm, -1.6mm), radius=0.2mm, height=1.6mm)
  lug505 = box(corner=(-21mm, -46mm, -1.6mm), size=(18mm, 18mm, 1.635mm))
  h506 = cylinder(axis=Z, base_centre=(-12mm, -37mm, -1.61mm), radius=3.2mm, height=1.655mm)
  lug505.subtract(h506)
  lug507 = box(corner=(3mm, -46mm, -1.6mm), size=(18mm, 18mm, 1.635mm))
  h508 = cylinder(axis=Z, base_centre=(12mm, -37mm, -1.61mm), radius=3.2mm, height=1.655mm)
  lug507.subtract(h508)
  v509 = cylinder(axis=Z, base_centre=(-17.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v510 = cylinder(axis=Z, base_centre=(-109.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v511 = cylinder(axis=Z, base_centre=(-13.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v512 = cylinder(axis=Z, base_centre=(-125.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v513 = cylinder(axis=Z, base_centre=(-57.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v514 = cylinder(axis=Z, base_centre=(66.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v515 = cylinder(axis=Z, base_centre=(118.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v516 = cylinder(axis=Z, base_centre=(122.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v517 = cylinder(axis=Z, base_centre=(-41.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v518 = cylinder(axis=Z, base_centre=(126.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v519 = cylinder(axis=Z, base_centre=(118.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v520 = cylinder(axis=Z, base_centre=(-33.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v521 = cylinder(axis=Z, base_centre=(126.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v522 = cylinder(axis=Z, base_centre=(-85.25mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v523 = cylinder(axis=Z, base_centre=(22.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v524 = cylinder(axis=Z, base_centre=(-101.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v525 = cylinder(axis=Z, base_centre=(-81.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v526 = cylinder(axis=Z, base_centre=(-85.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v527 = cylinder(axis=Z, base_centre=(-133.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v528 = cylinder(axis=Z, base_centre=(22.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v529 = cylinder(axis=Z, base_centre=(138.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v530 = cylinder(axis=Z, base_centre=(54.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v531 = cylinder(axis=Z, base_centre=(70.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v532 = cylinder(axis=Z, base_centre=(-97.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v533 = cylinder(axis=Z, base_centre=(-69.25mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v534 = cylinder(axis=Z, base_centre=(-81.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v535 = cylinder(axis=Z, base_centre=(-49.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v536 = cylinder(axis=Z, base_centre=(98.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v537 = cylinder(axis=Z, base_centre=(110.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v538 = cylinder(axis=Z, base_centre=(-117.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v539 = cylinder(axis=Z, base_centre=(18.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v540 = cylinder(axis=Z, base_centre=(-113.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v541 = cylinder(axis=Z, base_centre=(-129.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v542 = cylinder(axis=Z, base_centre=(-73.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v543 = cylinder(axis=Z, base_centre=(110.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v544 = cylinder(axis=Z, base_centre=(122.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v545 = cylinder(axis=Z, base_centre=(106.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v546 = cylinder(axis=Z, base_centre=(-77.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v547 = cylinder(axis=Z, base_centre=(50.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v548 = cylinder(axis=Z, base_centre=(114.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v549 = cylinder(axis=Z, base_centre=(-125.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v550 = cylinder(axis=Z, base_centre=(-65.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v551 = cylinder(axis=Z, base_centre=(118.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v552 = cylinder(axis=Z, base_centre=(-25.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v553 = cylinder(axis=Z, base_centre=(-93.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v554 = cylinder(axis=Z, base_centre=(-9.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v555 = cylinder(axis=Z, base_centre=(86.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v556 = cylinder(axis=Z, base_centre=(-117.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v557 = cylinder(axis=Z, base_centre=(-53.25mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v558 = cylinder(axis=Z, base_centre=(-113.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v559 = cylinder(axis=Z, base_centre=(30.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v560 = cylinder(axis=Z, base_centre=(-133.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v561 = cylinder(axis=Z, base_centre=(70.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v562 = cylinder(axis=Z, base_centre=(74.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v563 = cylinder(axis=Z, base_centre=(70.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v564 = cylinder(axis=Z, base_centre=(-129.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v565 = cylinder(axis=Z, base_centre=(-89.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v566 = cylinder(axis=Z, base_centre=(-45.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v567 = cylinder(axis=Z, base_centre=(42.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v568 = cylinder(axis=Z, base_centre=(82.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v569 = cylinder(axis=Z, base_centre=(110.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v570 = cylinder(axis=Z, base_centre=(-81.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v571 = cylinder(axis=Z, base_centre=(-121.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v572 = cylinder(axis=Z, base_centre=(106.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v573 = cylinder(axis=Z, base_centre=(90.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v574 = cylinder(axis=Z, base_centre=(-113.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v575 = cylinder(axis=Z, base_centre=(94.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v576 = cylinder(axis=Z, base_centre=(130.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v577 = cylinder(axis=Z, base_centre=(-25.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v578 = cylinder(axis=Z, base_centre=(38.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v579 = cylinder(axis=Z, base_centre=(-1.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v580 = cylinder(axis=Z, base_centre=(114.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v581 = cylinder(axis=Z, base_centre=(62.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v582 = cylinder(axis=Z, base_centre=(126.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v583 = cylinder(axis=Z, base_centre=(-97.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v584 = cylinder(axis=Z, base_centre=(-1.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v585 = cylinder(axis=Z, base_centre=(6.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v586 = cylinder(axis=Z, base_centre=(82.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v587 = cylinder(axis=Z, base_centre=(-57.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v588 = cylinder(axis=Z, base_centre=(22.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v589 = cylinder(axis=Z, base_centre=(14.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v590 = cylinder(axis=Z, base_centre=(54.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v591 = cylinder(axis=Z, base_centre=(-113.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v592 = cylinder(axis=Z, base_centre=(-57.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v593 = cylinder(axis=Z, base_centre=(98.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v594 = cylinder(axis=Z, base_centre=(-25.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v595 = cylinder(axis=Z, base_centre=(38.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v596 = cylinder(axis=Z, base_centre=(86.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v597 = cylinder(axis=Z, base_centre=(-65.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v598 = cylinder(axis=Z, base_centre=(86.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v599 = cylinder(axis=Z, base_centre=(-41.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v600 = cylinder(axis=Z, base_centre=(94.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v601 = cylinder(axis=Z, base_centre=(-121.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v602 = cylinder(axis=Z, base_centre=(66.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v603 = cylinder(axis=Z, base_centre=(-77.25mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v604 = cylinder(axis=Z, base_centre=(-73.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v605 = cylinder(axis=Z, base_centre=(82.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v606 = cylinder(axis=Z, base_centre=(22.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v607 = cylinder(axis=Z, base_centre=(142.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v608 = cylinder(axis=Z, base_centre=(-49.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v609 = cylinder(axis=Z, base_centre=(-85.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v610 = cylinder(axis=Z, base_centre=(-77.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v611 = cylinder(axis=Z, base_centre=(-53.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v612 = cylinder(axis=Z, base_centre=(90.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v613 = cylinder(axis=Z, base_centre=(2.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v614 = cylinder(axis=Z, base_centre=(-121.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v615 = cylinder(axis=Z, base_centre=(26.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v616 = cylinder(axis=Z, base_centre=(110.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v617 = cylinder(axis=Z, base_centre=(118.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v618 = cylinder(axis=Z, base_centre=(-101.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v619 = cylinder(axis=Z, base_centre=(26.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v620 = cylinder(axis=Z, base_centre=(-73.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v621 = cylinder(axis=Z, base_centre=(98.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v622 = cylinder(axis=Z, base_centre=(34.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v623 = cylinder(axis=Z, base_centre=(-113.25mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v624 = cylinder(axis=Z, base_centre=(102.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v625 = cylinder(axis=Z, base_centre=(94.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v626 = cylinder(axis=Z, base_centre=(-117.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v627 = cylinder(axis=Z, base_centre=(2.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v628 = cylinder(axis=Z, base_centre=(78.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v629 = cylinder(axis=Z, base_centre=(50.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v630 = cylinder(axis=Z, base_centre=(42.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v631 = cylinder(axis=Z, base_centre=(70.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v632 = cylinder(axis=Z, base_centre=(-61.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v633 = cylinder(axis=Z, base_centre=(-47.6mm, -45.2mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v634 = cylinder(axis=Z, base_centre=(-69.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v635 = cylinder(axis=Z, base_centre=(58.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v636 = cylinder(axis=Z, base_centre=(33.6mm, -45.2mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v637 = cylinder(axis=Z, base_centre=(122.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v638 = cylinder(axis=Z, base_centre=(58.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v639 = cylinder(axis=Z, base_centre=(-93.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v640 = cylinder(axis=Z, base_centre=(-97.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v641 = cylinder(axis=Z, base_centre=(74.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v642 = cylinder(axis=Z, base_centre=(-1.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v643 = cylinder(axis=Z, base_centre=(-69.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v644 = cylinder(axis=Z, base_centre=(130.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v645 = cylinder(axis=Z, base_centre=(-65.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v646 = cylinder(axis=Z, base_centre=(-37.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v647 = cylinder(axis=Z, base_centre=(-77.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v648 = cylinder(axis=Z, base_centre=(66.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v649 = cylinder(axis=Z, base_centre=(70.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v650 = cylinder(axis=Z, base_centre=(126.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v651 = cylinder(axis=Z, base_centre=(-85.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v652 = cylinder(axis=Z, base_centre=(66.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v653 = cylinder(axis=Z, base_centre=(-13.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v654 = cylinder(axis=Z, base_centre=(-69.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v655 = cylinder(axis=Z, base_centre=(-85.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v656 = cylinder(axis=Z, base_centre=(-105.25mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v657 = cylinder(axis=Z, base_centre=(-21.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v658 = cylinder(axis=Z, base_centre=(78.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v659 = cylinder(axis=Z, base_centre=(6.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v660 = cylinder(axis=Z, base_centre=(-105.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v661 = cylinder(axis=Z, base_centre=(58.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v662 = cylinder(axis=Z, base_centre=(-109.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v663 = cylinder(axis=Z, base_centre=(47.6mm, -45.2mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v664 = cylinder(axis=Z, base_centre=(86.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v665 = cylinder(axis=Z, base_centre=(134.75mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v666 = cylinder(axis=Z, base_centre=(-133.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v667 = cylinder(axis=Z, base_centre=(82.75mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v668 = cylinder(axis=Z, base_centre=(-141.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v669 = cylinder(axis=Z, base_centre=(82.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v670 = cylinder(axis=Z, base_centre=(62.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v671 = cylinder(axis=Z, base_centre=(110.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v672 = cylinder(axis=Z, base_centre=(58.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v673 = cylinder(axis=Z, base_centre=(-125.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v674 = cylinder(axis=Z, base_centre=(74.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v675 = cylinder(axis=Z, base_centre=(70.75mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v676 = cylinder(axis=Z, base_centre=(-32mm, -45.2mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v677 = cylinder(axis=Z, base_centre=(-65.25mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v678 = cylinder(axis=Z, base_centre=(106.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v679 = cylinder(axis=Z, base_centre=(18.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v680 = cylinder(axis=Z, base_centre=(-133.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v681 = cylinder(axis=Z, base_centre=(-117.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v682 = cylinder(axis=Z, base_centre=(-89.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v683 = cylinder(axis=Z, base_centre=(-65.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v684 = cylinder(axis=Z, base_centre=(-69.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v685 = cylinder(axis=Z, base_centre=(-81.25mm, -41.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v686 = cylinder(axis=Z, base_centre=(-57.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v687 = cylinder(axis=Z, base_centre=(-53.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v688 = cylinder(axis=Z, base_centre=(114.75mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v689 = cylinder(axis=Z, base_centre=(-137.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v690 = cylinder(axis=Z, base_centre=(122.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v691 = cylinder(axis=Z, base_centre=(-145.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v692 = cylinder(axis=Z, base_centre=(-81.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v693 = cylinder(axis=Z, base_centre=(-129.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v694 = cylinder(axis=Z, base_centre=(90.75mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v695 = cylinder(axis=Z, base_centre=(-30.4mm, -45.2mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v696 = cylinder(axis=Z, base_centre=(90.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v697 = cylinder(axis=Z, base_centre=(-81.25mm, -29.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v698 = cylinder(axis=Z, base_centre=(-61.25mm, -26mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v699 = cylinder(axis=Z, base_centre=(-93.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v700 = cylinder(axis=Z, base_centre=(114.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v701 = cylinder(axis=Z, base_centre=(-109.25mm, -45.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v702 = cylinder(axis=Z, base_centre=(-133.25mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v703 = cylinder(axis=Z, base_centre=(62.75mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v704 = cylinder(axis=Z, base_centre=(-125.25mm, -33.5mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v705 = cylinder(axis=Z, base_centre=(-17.25mm, -12mm, -1.6mm), radius=0.2mm, height=1.6mm)
  v706 = cylinder(axis=Z, base_centre=(66.75mm, -8mm, -1.6mm), radius=0.2mm, height=1.6mm)
  PL_L2.unite(PL_L4, pad437, face439, pad445, face447, pad453, face455, pv481..pv504, lug507, v605..v706)
  PL_L2.separate_bodies()
  PL_L1.unite(PL_L3, pad433, face435, pad441, face443, pad449, face451, pv457..pv480, lug505, v509..v604)
  PL_L1.separate_bodies()
boundaries and excitations:
  DCN: SignalNet Objects=PL_L2
  DCP: SignalNet Objects=PL_L1
  L1_J1: Source Faces=PL_L1.face(at (-100.5, -18.8, 0.035)) TerminalType=ConstantVoltage Net=DCP
  L1_J2: Source Faces=PL_L2.face(at (-88.5, -18.8, 0.035)) TerminalType=ConstantVoltage Net=DCN
  L2_J1: Source Faces=PL_L1.face(at (-6, -18.8, 0.035)) TerminalType=ConstantVoltage Net=DCP
  L2_J2: Source Faces=PL_L2.face(at (6, -18.8, 0.035)) TerminalType=ConstantVoltage Net=DCN
  L3_J1: Source Faces=PL_L1.face(at (88.5, -18.8, 0.035)) TerminalType=ConstantVoltage Net=DCP
  L3_J2: Source Faces=PL_L2.face(at (100.5, -18.8, 0.035)) TerminalType=ConstantVoltage Net=DCN
  LUG_P: Sink Faces=PL_L1.face(at (-12, -37, 0.035)) TerminalType=ConstantVoltage Net=DCP
  LUG_N: Sink Faces=PL_L2.face(at (12, -37, 0.035)) TerminalType=ConstantVoltage Net=DCN
setups:
  Setup1: Matrix AdaptiveFreq=1MHz Cap{MaxPass=2 MinPass=1 MinConvPass=1 PerError=10 PerRefine=30 AutoIncreaseAccuracy AccuracyLevel=Normal Solver_Type=Iterative} DC{Cond{MaxPass=10 MinPass=1 MinConvPass=1 PerError=2 PerRefine=30} Mult{MaxPass=1 MinPass=1 MinConvPass=1 PerError=1 PerRefine=30} AccuracyLevel=Normal} AC{MaxPass=8 MinPass=2 MinConvPass=1 PerError=2 PerRefine=30 ACRLSolverType=ACA} ErrorValue=0.1
source amplitudes:
  DCN:L1_J2, DCN:L2_J2, DCN:L3_J2, DCP:L2_J1, DCP:L3_J1: AC R/L Fields 0A
  DCP:L1_J1: AC R/L Fields 1A
  DCN: CG Fields 1V 0deg
  DCP: CG Fields 0V 0deg
  DCN:L1_J2, DCN:L2_J2, DCN:L3_J2, DCP:L2_J1, DCP:L3_J1: DC R/L Fields 0A
  DCP:L1_J1: DC R/L Fields 1A
